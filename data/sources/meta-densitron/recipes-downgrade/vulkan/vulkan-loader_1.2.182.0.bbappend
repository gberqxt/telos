# Modify the sourch branch from 'master' to 'main' to be politically correct
SRC_URI = "git://github.com/KhronosGroup/Vulkan-Loader.git;protocol=https;branch=main"
