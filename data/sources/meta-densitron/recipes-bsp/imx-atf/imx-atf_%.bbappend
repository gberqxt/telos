FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-AAOPEN-proposed-patch-2.1.patch"

